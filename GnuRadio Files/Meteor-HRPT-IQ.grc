options:
  parameters:
    generate_options: qt_gui
    id: casascsca
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.001'
    stop: '5'
    value: '0.05'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600*1109*8
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/sym_rate
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: 600*1109*2
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '25'
    type: complex
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'False'
    excess_bw: '1'
    samples_per_symbol: int(sps)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_divide_xx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_add_xx_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
